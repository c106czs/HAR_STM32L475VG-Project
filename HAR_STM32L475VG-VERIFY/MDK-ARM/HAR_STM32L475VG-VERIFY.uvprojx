# Keil uVision project HAR_STM32L475VG-VERIFY.uvprojx, settings and files
target HAR_STM32L475VG-VERIFY (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: HAR_STM32L475VG-VERIFY +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Core/Inc;   ../X-CUBE-AI/App;   ../X-CUBE-AI;   ../Middlewares/ST/AI/Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network_har.c network_har_data.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dfsdm.c i2c.c quadspi.c spi.c usart.c usb_otg.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network_har_generate_report.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime500_CM4_Keil.lib
software components: CMSIS:CORE 4.3.0
